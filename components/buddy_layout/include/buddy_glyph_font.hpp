#pragma once

#include <cctype>
#include <cstdint>

namespace buddy::layout {

/* Returns the five-column 5x7 bitmap for a supported character, or a blank
   glyph for anything unsupported. Shared by the non-LVGL fallback text
   renderers in buddy_ui and codex_ui (used on hosts without BUDDY_USE_LVGL_FONT,
   such as the host test/preview build). */
[[nodiscard]] inline const std::uint8_t *glyphBitmap(char value) noexcept
{
    static const std::uint8_t blank[5] = {0};
    static const std::uint8_t digits[10][5] = {
        {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},
        {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4b,0x31},
        {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
        {0x3c,0x4a,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
        {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1e},
    };
    static const std::uint8_t letters[26][5] = {
        {0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},
        {0x3e,0x41,0x41,0x41,0x22},{0x7f,0x41,0x41,0x22,0x1c},
        {0x7f,0x49,0x49,0x49,0x41},{0x7f,0x09,0x09,0x09,0x01},
        {0x3e,0x41,0x49,0x49,0x7a},{0x7f,0x08,0x08,0x08,0x7f},
        {0x00,0x41,0x7f,0x41,0x00},{0x20,0x40,0x41,0x3f,0x01},
        {0x7f,0x08,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
        {0x7f,0x02,0x0c,0x02,0x7f},{0x7f,0x04,0x08,0x10,0x7f},
        {0x3e,0x41,0x41,0x41,0x3e},{0x7f,0x09,0x09,0x09,0x06},
        {0x3e,0x41,0x51,0x21,0x5e},{0x7f,0x09,0x19,0x29,0x46},
        {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7f,0x01,0x01},
        {0x3f,0x40,0x40,0x40,0x3f},{0x1f,0x20,0x40,0x20,0x1f},
        {0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,0x08,0x14,0x63},
        {0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},
    };
    static const std::uint8_t dash[5] = {0x08,0x08,0x08,0x08,0x08};
    static const std::uint8_t slash[5] = {0x20,0x10,0x08,0x04,0x02};
    static const std::uint8_t colon[5] = {0x00,0x36,0x36,0x00,0x00};
    static const std::uint8_t percent[5] = {0x63,0x13,0x08,0x64,0x63};
    static const std::uint8_t dot[5] = {0x00,0x60,0x60,0x00,0x00};
    static const std::uint8_t exclamation[5] = {0x00,0x00,0x5f,0x00,0x00};
    if (value >= '0' && value <= '9') return digits[value - '0'];
    value = static_cast<char>(toupper(static_cast<unsigned char>(value)));
    if (value >= 'A' && value <= 'Z') return letters[value - 'A'];
    if (value == '-') return dash;
    if (value == '/') return slash;
    if (value == ':') return colon;
    if (value == '%') return percent;
    if (value == '.') return dot;
    if (value == '!') return exclamation;
    return blank;
}

}  // namespace buddy::layout
